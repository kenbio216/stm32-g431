<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\the-first-try-demo001.ewp</path>
  </project>
  <batchBuild />
</workspace>
